# Repository ExploreEmbedded/MCUs-Base-Board-DVB-15001

## KiCad design Hardware/MCU_BaseBoard.kicad_pcb

Parts:
C1, C2: 100uF, 25V
C3: 0.1uf
D1: BRIDGE
D3, D16: LED
D15: DIODE
IC2: LM1117
JP10: JUMPER
K4: CONN_3
P1: CONN_01X02
P2, P14: CONN_01X20
P3, P4, P5, P25, P26, P27, P29: CONN_01X04
P6, P7, P8, P9, P10: CONN_1
P30: CONN_01X07
R1, R2: 10k
R10: 10K
R27: 470
SW18: INT0
SW19: INT1
SW20: SPST
U1: 7805
U5: 40PIN_Breakout

Connections:
3.3V: IC2.2 (OUT), IC2.4 (OUT), P5.1, P5.2, P5.3, P5.4; also elsewhere on the board
9V/12V: C1.1, D1.3 (+), P3.1, P3.2, P3.3, P3.4, R10.2, U1.VI; also elsewhere on the board
+5V: D15.2 (K), IC2.3 (IN), P4.1, P4.2, P4.3, P4.4, P14.1, P29.4, P30.3, R1.1, R2.1, R27.2, U5.40; also elsewhere on the board
/S1: P1.1, R1.2, SW18.2
/S2: P1.2, R2.2, SW19.2
GND: C1.2, C2.2, D1.1 (-), D3.2 (K), D16.2 (K), IC2.1 (GND), P14.2, P25.1, P25.2, P25.3, P25.4, P26.1, P26.2, P26.3, P26.4, P27.1, P27.2, P27.3, P27.4, P29.3, P30.1, SW18.1, SW19.1, U1.GND, U5.39; also elsewhere on the board
unnamed: C2.1, D15.1 (A), U1.VO
unnamed: C3.1, JP10.2
unnamed: D1.2, K4.2 (PM), K4.3
unnamed: D1.4, SW20.2
unnamed: D3.1 (A), R10.1
unnamed: D16.1 (A), R27.1
unnamed: JP10.1, P30.7
unnamed: K4.1, SW20.1
unnamed: P2.3, U5.3
unnamed: P2.4, U5.4
unnamed: P2.5, U5.5
unnamed: P2.6, U5.6
unnamed: P2.7, U5.7
unnamed: P2.8, U5.8
unnamed: P2.9, U5.9
unnamed: P2.10, U5.10
unnamed: P2.11, U5.11
unnamed: P2.13, U5.13
unnamed: P2.14, U5.14
unnamed: P2.15, U5.15
unnamed: P2.16, U5.16
unnamed: P2.17, U5.17
unnamed: P2.18, U5.18
unnamed: P2.19, U5.19
unnamed: P2.20, U5.20
unnamed: P14.3, U5.38
unnamed: P14.4, U5.37
unnamed: P14.5, U5.36
unnamed: P14.6, U5.35
unnamed: P14.7, U5.34
unnamed: P14.8, U5.33
unnamed: P14.9, U5.32
unnamed: P14.10, U5.31
unnamed: P14.11, U5.30
unnamed: P14.12, U5.29
unnamed: P14.13, U5.28
unnamed: P14.14, U5.27
unnamed: P14.15, U5.26
unnamed: P14.16, U5.25
unnamed: P14.17, U5.24
unnamed: P14.18, U5.23
unnamed: P14.19, U5.22
unnamed: P14.20, U5.21
RST: C3.2, P2.12, U5.12
RX: P2.1, P29.2, P30.4, U5.1
TX: P2.2, P29.1, P30.5, U5.2

Notes on the sheet:
Power Supply
Create a 40 pin component with the name Explore MCU Breakout and also a footprint for it. Do not put it as individucal connectors, people may find difficult to understand what these connectors are!
If this LED indicates LED Power connect it to VBUS, don't leave stand alone
Add SPI LCD

Parts:
AFF1, AFF2, AFF3, AFF4: LTS-6960HR
D2: RL1
D4: RL2
D5, D6: 1N40XX
JP1: RELAY; SparkFun-JST-2-PTH-NS
JP2, JP3: M03-SCREW-5MM; SparkFun-SCREWTERMINAL-5MM-3
JP4: SWITCH_ARRAY; SparkFun-1X08_LOCK
K1, K2: RELAYPTH
P11: CONN_4
P12: CONN_8
P13: CONN_1
Q1, Q2, Q3, Q4, Q5, Q6, Q7: BC547; TO92
R3, R4, R6: 1K
R5, R7, R8, R9: 1K
R21, R22, R23, R24: 68
RR2: RR8
S1: SW_DIP-8; SparkFun-DIPSWITCH-08
SG1: BUZZERPTH; SparkFun-BUZZER-12MM

Connections:
+5V: D5.2 (K), D6.2 (K), K1.5 (COIL1), K2.5 (COIL1), Q5.1 (C), R21.2, R22.2, R23.2, R24.2, RR2.1 (COM); also elsewhere on the board
/7Segment/DP: AFF1.5 (DP), AFF2.5 (DP), AFF3.5 (DP), AFF4.5 (DP), P12.8
/7Segment/SG-1: AFF1.7 (a), AFF2.7 (a), AFF3.7 (a), AFF4.7 (a), P12.1
/7Segment/SG-2: AFF1.6 (b), AFF2.6 (b), AFF3.6 (b), AFF4.6 (b), P12.2
/7Segment/SG-3: AFF1.4 (c), AFF2.4 (c), AFF3.4 (c), AFF4.4 (c), P12.3
/7Segment/SG-4: AFF1.2 (d), AFF2.2 (d), AFF3.2 (d), AFF4.2 (d), P12.4
/7Segment/SG-5: AFF1.1 (e), AFF2.1 (e), AFF3.1 (e), AFF4.1 (e), P12.5
/7Segment/SG-6: AFF1.9 (f), AFF2.9 (f), AFF3.9 (f), AFF4.9 (f), P12.6
/7Segment/SG-7: AFF1.10 (g), AFF2.10 (g), AFF3.10 (g), AFF4.10 (g), P12.7
GND: Q1.3 (E), Q2.3 (E), S1.9, S1.10, S1.11, S1.12, S1.13, S1.14, S1.15, S1.16, SG1.2; also elsewhere on the board
unnamed: AFF1.3 (C.A.), Q3.3 (E)
unnamed: AFF2.3 (C.A.), Q4.3 (E)
unnamed: AFF3.3 (C.A.), Q6.3 (E)
unnamed: AFF4.3 (C.A.), Q7.3 (E)
unnamed: D2.1 (A), JP1.2
unnamed: D2.2 (K), R3.1
unnamed: D4.1 (A), JP1.1
unnamed: D4.2 (K), R4.1
unnamed: D5.1 (A), K1.1 (COIL2), Q1.1 (C)
unnamed: D6.1 (A), K2.1 (COIL2), Q2.1 (C)
unnamed: JP2.1, K1.4 (NC)
unnamed: JP2.2, K1.2 (MAIN)
unnamed: JP2.3, K1.3 (NO)
unnamed: JP3.1, K2.4 (NC)
unnamed: JP3.2, K2.2 (MAIN)
unnamed: JP3.3, K2.3 (NO)
unnamed: JP4.1, RR2.9, S1.8
unnamed: JP4.2, RR2.8, S1.7
unnamed: JP4.3, RR2.7, S1.6
unnamed: JP4.4, RR2.6, S1.5
unnamed: JP4.5, RR2.5, S1.4
unnamed: JP4.6, RR2.4, S1.3
unnamed: JP4.7, RR2.3, S1.2
unnamed: JP4.8, RR2.2, S1.1
unnamed: P11.1, R5.2
unnamed: P11.2, R7.2
unnamed: P11.3, R8.2
unnamed: P11.4, R9.2
unnamed: P13.1, R6.1
unnamed: Q1.2 (B), R3.2
unnamed: Q2.2 (B), R4.2
unnamed: Q3.1 (C), R21.1
unnamed: Q3.2 (B), R5.1
unnamed: Q4.1 (C), R22.1
unnamed: Q4.2 (B), R7.1
unnamed: Q5.2 (B), R6.2
unnamed: Q5.3 (E), SG1.1
unnamed: Q6.1 (C), R23.1
unnamed: Q6.2 (B), R8.1
unnamed: Q7.1 (C), R24.1
unnamed: Q7.2 (B), R9.1

Notes on the sheet:
7Segments
Relay
Buzzer
Switches

Parts:
D7, D8, D9, D10, D11, D12, D13, D14: LED
IC1: L293D; sgs-thom-DIL16
JP5: MATRIX 4X4; SparkFun-1X08_LOCK
JP6: MOTAR CNTRL; SparkFun-JST-4-PTH
JP7: led array; SparkFun-1X08_LOCK
JP8, JP9: m1; SparkFun-JST-2-PTH-NS
K3: I2C
R14: 3.3k
R15: 3.3K
R16, R29, R30, R31, R32, R33, R34, R35: 470
RR1: RR8
SW2: C
SW3: D
SW4: E
SW5: F
SW6: 9
SW7: 0
SW8: A
SW9: B
SW10: 5
SW11: 6
SW12: 7
SW13: 8
SW14: 1
SW15: 2
SW16: 3
SW17: 4
U2: 24C16
U3: DS1307
U4: BATTERY
X1: CRYSTAL

Connections:
9V/12V: IC1.8 (VCC2); also elsewhere on the board
+5V: IC1.1 (1,2EN), IC1.9 (3,4EN), IC1.16 (VCC1), R14.1, R15.1, RR1.1 (COM), U2.8 (VCC), U3.8 (VCC); also elsewhere on the board
/Key Pad/M1a: IC1.2 (1A), JP6.4
/Key Pad/M1b: IC1.7 (2A), JP6.3
/Key Pad/M1c: IC1.3 (1Y), JP8.1
/Key Pad/M1d: IC1.6 (2Y), JP8.2
/Key Pad/M2a: IC1.15 (4A), JP6.2
/Key Pad/M2b: IC1.10 (3A), JP6.1
/Key Pad/M2c: IC1.14 (4Y), JP9.1
/Key Pad/M2d: IC1.11 (3Y), JP9.2
/Key Pad/OUT: K3.1, U3.7 (SQW/OUT)
/Key Pad/SCL: K3.2 (PM), R15.2, U2.6 (SCL), U3.6 (SCL)
/Key Pad/SDA: K3.3, R14.2, U2.5 (SDA), U3.5 (SDA)
GND: D7.2 (K), D8.2 (K), D9.2 (K), D10.2 (K), D11.2 (K), D12.2 (K), D13.2 (K), D14.2 (K), IC1.4 (GND1), IC1.5 (GND2), IC1.12 (GND4), IC1.13 (GND3), U2.1 (A0), U2.2 (A1), U2.3 (A2), U2.4 (GND), U2.7 (WP), U3.4 (GND), U4.2 (-), X1.3; also elsewhere on the board
unnamed: D7.1 (A), R29.2
unnamed: D8.1 (A), R30.2
unnamed: D9.1 (A), R31.2
unnamed: D10.1 (A), R32.2
unnamed: D11.1 (A), R33.2
unnamed: D12.1 (A), R34.2
unnamed: D13.1 (A), R35.2
unnamed: D14.1 (A), R16.2
unnamed: JP5.1, RR1.2, SW2.1, SW3.1, SW4.1, SW5.1
unnamed: JP5.2, RR1.3, SW6.1, SW7.1, SW8.1, SW9.1
unnamed: JP5.3, RR1.4, SW10.1, SW11.1, SW12.1, SW13.1
unnamed: JP5.4, RR1.5, SW14.1, SW15.1, SW16.1, SW17.1
unnamed: JP5.5, RR1.6, SW2.2, SW6.2, SW10.2, SW14.2
unnamed: JP5.6, RR1.7, SW3.2, SW7.2, SW11.2, SW15.2
unnamed: JP5.7, RR1.8, SW4.2, SW8.2, SW12.2, SW16.2
unnamed: JP5.8, RR1.9, SW5.2, SW9.2, SW13.2, SW17.2
unnamed: JP7.1, R16.1
unnamed: JP7.2, R35.1
unnamed: JP7.3, R34.1
unnamed: JP7.4, R33.1
unnamed: JP7.5, R32.1
unnamed: JP7.6, R31.1
unnamed: JP7.7, R30.1
unnamed: JP7.8, R29.1
unnamed: U3.1 (X1), X1.2
unnamed: U3.2 (X2), X1.1
unnamed: U3.3 (VBAT), U4.1 (+)

Notes on the sheet:
EEPROM
RTC
LED
KEY PAD

Parts:
C4: 100nF
C5: 10uF
D17, D18, D19: ZENER
LCD1: LCD_2X16_SIL; lcd_2x16_led_backlight-HY-1602F
P22: CONN_01X03
P28, P32: CONN_01X05
P31: CONN_01X08
R13: 2.2k
R17, R18: 10k
R19: 1K
R20, R28: 33K
R25: LDR
R26: 10k
RV1: TS
RV2: POT
RV3, RV4: VO
SD1: MICRO_SD
U7: LCD-jhd12864e-xl

Connections:
3.3V: C4.1, C5.1, P22.1, R17.1, R18.1, R19.1, R20.2, R28.2, SD1.4 (VDD); also elsewhere on the board
+5V: LCD1.2 (VCC), LCD1.15 (LEDA), P22.3, RV3.3, RV4.3, U7.2 (VDD), U7.17 (RST), U7.19 (LED+); also elsewhere on the board
/ADC/ADC_REF: P22.2, R26.1, RV1.1, RV2.1
/ADC/IN2: R25.1, R26.2; also elsewhere on the board
/ADC/MISO: P28.4, SD1.7 (DATA0)
/ADC/MOSI: D18.2 (K), P28.2, R18.2, SD1.3 (CMD)
/ADC/POT: RV2.2; also elsewhere on the board
/ADC/SCK: D19.2 (K), P28.3, SD1.5 (CLK)
/ADC/SD_DETECT: P28.5, R19.2, SD1.9 (CD)
/ADC/SSEL: D17.2 (K), P28.1, R17.2, SD1.2 (CD/DATA3)
/ADC/TS: RV1.2; also elsewhere on the board
CS1: P32.2, U7.15 (CS1)
CS2: P32.1, U7.16 (CS2)
DATA0: LCD1.7 (DB0), P31.8, U7.7 (DB0)
DATA1: LCD1.8 (DB1), P31.7, U7.8 (DB1)
DATA2: LCD1.9 (DB2), P31.6, U7.9 (DB2)
DATA3: LCD1.10 (DB3), P31.5, U7.10 (DB3)
DATA4: LCD1.11 (DB4), P31.4, U7.11 (DB4)
DATA5: LCD1.12 (DB5), P31.3, U7.12 (DB5)
DATA6: LCD1.13 (DB6), P31.2, U7.13 (DB6)
DATA7: LCD1.14 (DB7), P31.1, U7.14 (DB7)
E: LCD1.6 (E), P32.3, U7.6 (E)
GND: C4.2, C5.2, D17.1 (A), D18.1 (A), D19.1 (A), LCD1.1 (VSS), R13.2, R25.2, RV1.3, RV2.3, RV3.1, SD1.6 (VSS), SD1.10 (SH1), SD1.11 (SH2), SD1.12 (SH3), SD1.13 (SH4), U7.1 (VSS); also elsewhere on the board
LEDK: LCD1.16 (LEDK), R13.1, U7.20 (LED-)
unnamed: R20.1, SD1.8 (DATA1)
unnamed: R28.1, SD1.1 (DATA2)
R/W: LCD1.5 (R/W), P32.4, U7.5 (R/~W)
RS: LCD1.4 (RS), P32.5, U7.4 (RS)
VEE: RV4.1, U7.18 (VEE)
VO: LCD1.3 (VO), RV3.2
VO1: RV4.2, U7.3 (VO)

Notes on the sheet:
ADC
LCD
connect pots to respective LCDs.

Board: 2 copper layers, 180.0 x 125.0 mm, 146 parts (2 on the bottom side), 171 nets.

Other parts of the board:
P15: CONN_01X03; Pin_Header_Straight_1x03
P16: CONN_01X06; Pin_Header_Straight_1x06
P17: CONN_01X04; Pin_Header_Straight_1x04

Their connections:
3.3V: P16.1; also elsewhere on the board
/ADC/IN2: P15.1; also elsewhere on the board
/ADC/POT: P15.2; also elsewhere on the board
/ADC/TS: P15.3; also elsewhere on the board
GND: P16.2; also elsewhere on the board
unnamed: P16.3, P17.1
unnamed: P16.4, P17.2
unnamed: P16.5, P17.3
unnamed: P16.6, P17.4

File Hardware/BOM.xlsx:

Id | Designator | Package | Quantity | Designation | Supplier and ref
1 | SW20 | SPSPT_XL | 1 | SPST
2 | LCD1 | WC1602A | 1 | LCD_2X16_SIL
3 | C1,C2 | c_elec_8x10.5 | 2 | 100uF, 25V
4 | C3 | C_1206_HandSoldering | 1 | 0.1uf
5 | C4 | C_1206_HandSoldering | 1 | 100nF
6 | C5 | C_1206_HandSoldering | 1 | 10uF
7 | D2 | LED-1206 | 1 | RL1
8 | D3,D7,D8,D9,D10,D11,D12,D13,D14,D16 | LED-1206 | 10 | LED
9 | D4 | LED-1206 | 1 | RL2
10 | D5,D6 | Diode-SMA_Handsoldering | 2 | 1N40XX
11 | D15 | Diode-SMA_Handsoldering | 1 | DIODE
12 | D17,D18,D19 | Diode-SMA_Handsoldering | 3 | ZENER
13 | IC1 | DIP-16__300_ELL | 1 | L293D
14 | IC2 | SOT-223 | 1 | LM1117
15 | JP2,JP3 | bornier3 | 2 | M03-SCREW-5MM
16 | JP4 | Pin_Header_Straight_1x08 | 1 | SWITCH_ARRAY
17 | JP5 | Pin_Header_Straight_1x08 | 1 | MATRIX 4X4
18 | JP6 | Pin_Header_Straight_1x04 | 1 | MOTAR CNTRL
19 | JP7 | Pin_Header_Straight_1x08 | 1 | led array
20 | JP8,JP9 | bornier2 | 2 | m1
21 | K3 | Pin_Header_Straight_1x03 | 1 | I2C
22 | K4 | BARREL_JACK | 1 | CONN_3
23 | P3,P4,P5,P25,P26,P27,P29,P17 | Pin_Header_Straight_1x04 | 8 | CONN_01X04
24 | P6,P7,P8,P9,P10 | 1pin | 5 | CONN_1
25 | P11 | Pin_Header_Straight_1x04 | 1 | CONN_4
26 | P12 | Pin_Header_Straight_1x08 | 1 | CONN_8
27 | P13 | Pin_Header_Straight_1x01 | 1 | CONN_1
28 | P22,P15 | Pin_Header_Straight_1x03 | 2 | CONN_01X03
29 | P28,P32 | Pin_Header_Straight_1x05 | 2 | CONN_01X05
30 | Q2,Q3,Q4,Q5,Q6,Q7,Q1 | sc70 | 7 | BC547
31 | R1,R2,R17,R18,R26 | R_1206_HandSoldering | 5 | 10k
32 | R3,R4,R5,R6,R7,R8,R9,R19 | R_1206_HandSoldering | 8 | 1K
33 | R10 | R_1206_HandSoldering | 1 | 10K
34 | R13 | R_1206_HandSoldering | 1 | 2.2k
35 | R14 | R_1206_HandSoldering | 1 | 3.3k
36 | R15 | R_1206_HandSoldering | 1 | 3.3K
37 | R16,R27,R29,R30,R31,R32,R33,R34,R35 | R_1206_HandSoldering | 9 | 470
38 | R20,R28 | R_1206_HandSoldering | 2 | 33K
39 | R21,R22,R23,R24 | R_1206_HandSoldering | 4 | 68
40 | RR1,RR2 | r_pack8 | 2 | RR8
41 | RV1 | Potentiometer_Triwood_RM-065 | 1 | TS
42 | RV2 | Potentiometer_Triwood_RM-065 | 1 | POT
43 | RV3,RV4 | Potentiometer_Triwood_RM-065 | 2 | VO
44 | S1 | DIP-16__300_ELL | 1 | SW_DIP-8
45 | SD1 | Micro_SD | 1 | MICRO_SD
46 | SG1 | Buzzer_12x9.5RM7.6 | 1 | BUZZERPTH
47 | SW2 | SW_PUSH_SMALL_2pin_3D_xl | 1 | C
48 | SW3 | SW_PUSH_SMALL_2pin_3D_xl | 1 | D
49 | SW4 | SW_PUSH_SMALL_2pin_3D_xl | 1 | E
50 | SW5 | SW_PUSH_SMALL_2pin_3D_xl | 1 | F
51 | SW6 | SW_PUSH_SMALL_2pin_3D_xl | 1 | 9
52 | SW7 | SW_PUSH_SMALL_2pin_3D_xl | 1 | 0
53 | SW8 | SW_PUSH_SMALL_2pin_3D_xl | 1 | A
54 | SW9 | SW_PUSH_SMALL_2pin_3D_xl | 1 | B
55 | SW10 | SW_PUSH_SMALL_2pin_3D_xl | 1 | 5
56 | SW11 | SW_PUSH_SMALL_2pin_3D_xl | 1 | 6
57 | SW12 | SW_PUSH_SMALL_2pin_3D_xl | 1 | 7
58 | SW13 | SW_PUSH_SMALL_2pin_3D_xl | 1 | 8
59 | SW14 | SW_PUSH_SMALL_2pin_3D_xl | 1 | 1
60 | SW15 | SW_PUSH_SMALL_2pin_3D_xl | 1 | 2
61 | SW16 | SW_PUSH_SMALL_2pin_3D_xl | 1 | 3
62 | SW17 | SW_PUSH_SMALL_2pin_3D_xl | 1 | 4
63 | SW18 | SW_PUSH_SMALL_2pin_3D_xl | 1 | INT0
64 | SW19 | SW_PUSH_SMALL_2pin_3D_xl | 1 | INT1
65 | U2 | DIP-8__300_ELL | 1 | 24C16
66 | U3 | DIP-8__300_ELL | 1 | DS1307
67 | U4 | BATT_rtc_XL | 1 | BATTERY
68 | U7 | Pin_Header_Straight_1x20 | 1 | LCD-jhd12864e-xl
69 | JP1 | Pin_Header_Straight_1x02 | 1 | RELAY
70 | JP10 | Pin_Header_Straight_1x02 | 1 | JUMPER
71 | K1,K2 | XL-RELAY-12 | 2 | RELAYPTH
72 | U1 | LM78XX_v1_XL1 | 1 | 7805
73 | R25 | Pin_Header_Straight_1x02 | 1 | LDR
74 | P30 | Pin_Header_Straight_1x07 | 1 | CONN_01X07
75 | P31 | Pin_Header_Straight_1x08 | 1 | CONN_01X08
76 | P1 | Pin_Header_Straight_1x02 | 1 | CONN_01X02
77 | AFF2,AFF3,AFF4,AFF1 | 7SegmentLED_LTS6760_LTS6780 | 4 | LTS-6960HR
78 | D1 | bridge_smd_xl | 1 | BRIDGE
79 | P2,P14 | Pin_Header_Straight_1x20 | 2 | CONN_01X20
80 | X1 | RTC_Crystal | 1 | CRYSTAL_SMD
81 | U5 | 40pin_breakout | 1 | 40PIN_Breakout
82 | P16 | Pin_Header_Straight_1x06 | 1 | CONN_01X06

## Commit log

2015-05-22 MCU Base board files
2015-05-23 verified schematic and component placement
    corrections written on schematic and layout
2015-05-23 test
2015-06-08 added new files
2015-06-20 Added final Files
2015-08-20 added files
